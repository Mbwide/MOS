# Keil uVision project m_os.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mos
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\mos;..\mos\ports;..\mos\core\include;..\stm32;..\stm32\CORE;..\stm32\STM32F10x_FWLib\inc;..\user\hardware;..\user\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c
    ../mos/: mos_user_config.h
  group hardware
    ../user/system/: bsp_sys.c
    ../user/hardware/: bsp_led.c bsp_timer.c bsp_usart.c lcd.c bsp_delay.c
  group mos/core
    ../mos/core/: mos_task.c mos_ipc.c mos_heap.c mos_misc.c mos_init.c mos_sys.c mos_tick.c mos_shell.c
  group mos/ports
    ../mos/ports/: mos_port.c mos_hw.c mos_port_asm.s
  group mos/include
    ../mos/ports/: mos_typedef.h
    ../mos/core/include/: mos_list.h mos_task.h mos_misc.h mos_init.h
  group lib
    ../stm32/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group core
    ../stm32/CORE/: core_cm3.c startup_stm32f10x_hd.s
    ../stm32/: stm32f10x_it.c system_stm32f10x.c
