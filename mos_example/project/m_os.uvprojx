# Keil uVision project m_os.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Ma_RT_Thread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\mos;..\mos\ports;..\mos\core\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.c
    ../mos/: mos_user_config.h
  group mos/core
    ../mos/core/: mos_misc.c mos_task.c mos_init.c mos_sys.c mos_tick.c
    ../mos/: mos_user_config.h
  group mos/ports
    ../mos/ports/: mos_hw.c mos_port_asm.s mos_port.c
  group mos/include
    ../mos/ports/: mos_typedef.h
    ../mos/core/include/: mos_list.h mos_task.h mos_misc.h mos_init.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
